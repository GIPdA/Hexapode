# Keil uVision project Hexapode.uvproj, settings and files
target Hexapode (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Hexapode
  c flags: Optim=1
  c include: .;..\..\FreeRTOS-Source\include;..\..\FreeRTOS-Source\portable\RVDS\ARM_CM3;..\..\FreeRTOS-Source\demo_code
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group FreeRTOS_source
    ../../FreeRTOS-Source/: list.c queue.c tasks.c
    ../../FreeRTOS-Source/portable/MemMang/: heap_1.c
    ../../FreeRTOS-Source/portable/RVDS/ARM_CM3/: port.c
    ../FreeRTOS-Source/: timers.c
  group Hexapode_source
    ./: main.c servodriver.c uart0.c decoder.c decoder_servoposition.c
    ../../FreeRTOS-Source/demo_code/: basic_io.c
  group System_source
    ./: system_LPC17xx.c startup_LPC17xx.s
